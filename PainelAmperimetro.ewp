# IAR project PainelAmperimetro.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F51115 R5F51115
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x400
  General.HeapSize: 0x400
  ICCRX.CCDefines: __RX; __LIT; USB_FUNCSEL_PP=USB_HOST_PP; USB_PORTSEL_PP=USB_1PORT_PP; USB_TFAT_USE_PP; tSEM_CABO
  ICCRX.CCIncludePath2: user_src; cg_src; usb_src/USBSTDFW/inc; usb_src/HMSC/inc; usb_src/HMSC/tfat/lib_src; usb_src/HIDFW/inc; usb_src/HwResource/inc; usb_src/SmplMain/inc; dataflash; dataflash/FDL; dataflash/FDL/lib
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: V7427R01.hex
  ILINK.IlinkOutputFile: V7427FIRR01.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  group cg_src
    cg_src/: Buzzer.c Buzzer.h Entradas.c Entradas.h HD44780.c HD44780.h INA219.c INA219.h LCDBitmap.c LCDBitmap.h r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_cmt.c r_cg_cmt.h r_cg_cmt_user.c r_cg_icu.c r_cg_icu.h r_cg_icu_user.c r_cg_intprg.c r_cg_iwdt.c r_cg_iwdt.h r_cg_iwdt_user.c r_cg_lpc.c r_cg_lpc.h r_cg_lpc_user.c r_cg_macrodriver.h r_cg_main.c r_cg_main.h r_cg_mtu2.c r_cg_mtu2.h r_cg_mtu2_user.c r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_s12adb.c r_cg_s12adb.h r_cg_s12adb_user.c r_cg_systeminit.c r_cg_userdefine.h r_gpio_rx111.c r_gpio_rx111.h SoftwareI2C.c SoftwareI2C.h
  group dataflash
    dataflash/: fdl_cfg.h fdl_descriptor.c fdl_descriptor.h
  group dataflash/FDL
    dataflash/FDL/: r_fdl.h r_typedefs.h
  group dataflash/FDL/lib
    dataflash/FDL/lib/: r_fdl_env.h r_fdl_global.h r_fdl_hw_access.c r_fdl_types.h r_fdl_user_if.c
  group usb_src/HIDFW
    usb_src/HIDFW/src/: r_usb_hhid_api.c r_usb_hhid_driver.c
    usb_src/HIDFW/inc/: r_usb_hhid_api.h r_usb_hhid_define.h r_usb_hhid_usrcfg.h
  group usb_src/HMSC
    usb_src/HMSC/src/: r_usb_hmsc_api.c r_usb_hmsc_ddi.c r_usb_hmsc_driver.c r_usb_hmsc_fsi.c r_usb_hmsc_hci.c r_usb_hstorage_driver.c r_usb_hstorage_driver_api.c
  group usb_src/HMSC/TFAT
    usb_src/HMSC/TFAT/lib_src/: r_tfat_drv_if.c
    usb_src/HMSC/TFAT/lib/: r_TinyFAT_little.a
  group usb_src/HwResource
    usb_src/HwResource/inc/: hw_resource.h r_usb_regaccess.h r_usb_usbip.h
  group usb_src/SmplMain
    usb_src/SmplMain/APL/: r_usb_hhid_apl.c r_usb_hmsc_apl.c
  group usb_src/USBSTDFW
    usb_src/USBSTDFW/inc/: r_usb_api.h r_usb_cdefusbip.h r_usb_ckernelid.h r_usb_ctypedef.h r_usb_usrconfig.h
    usb_src/USBSTDFW/src/: r_usb_cstdapi.c r_usb_cstdfunction.c r_usb_h1port.c r_usb_h2port.c r_usb_hbc.c r_usb_hdriver.c r_usb_hdriverapi.c r_usb_hp0function.c r_usb_hp1function.c r_usb_hport.h r_usb_iodefine.h r_usb_pbc.c r_usb_pdriver.c r_usb_pdriverapi.c
  group user_src
    user_src/: Fonts16.h r_usb_regaccess.h r_usb_usbip.h r_user_extempsensor.h r_user_hwrctrl.c r_user_hwrctrl.h r_user_includes.h r_user_intempsensor.h rx_mcu.c
